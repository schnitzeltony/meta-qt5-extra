require ${BPN}.inc 

inherit native

DEPENDS += "qtscript-native gettext-native"
