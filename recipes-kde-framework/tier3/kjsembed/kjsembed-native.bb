require ${BPN}.inc

inherit native

DEPENDS += "qtsvg-native"
