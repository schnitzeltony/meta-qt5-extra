require recipes-graphics/xorg-lib/xcb-util.inc

DEPENDS += "xcb-util xcb-util-renderutil xcb-util-image"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://COPYING;md5=ce469b61c70ff8d7cce0547476891974"

SRC_URI[md5sum] = "88e70d92ff5616d406ce5b1b62e0c58b"
SRC_URI[sha256sum] = "ed65367b810d47ab637011585135f4a84dd12e235dddcd3b26e0cfb3be21fb3a"
