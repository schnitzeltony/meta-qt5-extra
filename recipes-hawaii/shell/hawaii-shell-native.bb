require ${BPN}.inc

inherit native

SRC_URI += "file://0001-native-build-and-install-enhancedqdbusxml2cpp-only.patch"
