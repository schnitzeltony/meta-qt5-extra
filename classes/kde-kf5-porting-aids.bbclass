inherit kde-kf5

SRC_URI = "${KDE_MIRROR}/stable/frameworks/5.38/portingAids/${BPN}-${PV}.tar.xz"
