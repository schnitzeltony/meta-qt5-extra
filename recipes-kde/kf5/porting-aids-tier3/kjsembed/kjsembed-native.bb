LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"

CMAKE_DUMMY_BINARIES = "kjscmd5"

inherit cmake-native-dummy


