require ${BPN}.inc

inherit native

SRC_URI += "file://0002-keep-gui-stuff-out-of-native-build.patch"
