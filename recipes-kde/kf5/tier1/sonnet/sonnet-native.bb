require ${BPN}.inc

inherit native

SRC_URI += " \
	file://0001-build-and-install-parsetrigrams-only-we-need-the-nat.patch \
"
