require ${BPN}.inc

SRC_URI += " \
    file://0001-avoid-autotests.patch \
"

inherit native
