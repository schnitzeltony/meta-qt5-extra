require ${BPN}.inc

inherit native

DEPENDS += "qtxmlpatterns-native"

SRC_URI += "file://0001-native-build-and-install-katehighlightingindexer-onl.patch"
