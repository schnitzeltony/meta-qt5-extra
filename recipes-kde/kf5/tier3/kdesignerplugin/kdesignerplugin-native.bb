require ${BPN}.inc

inherit native

DEPENDS += " \
    qttools-native \
    kcoreaddons-native \
    kconfig-native \
    kdoctools-native \
"

