require ${BPN}.inc

inherit native

DEPENDS += " \
	qttools-native \
"

