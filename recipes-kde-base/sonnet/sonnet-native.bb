require ${BPN}.inc

inherit native

SRC_URI += " \
	file://0001-install-parsetrigrams-we-need-the-native-one-for-cro.patch \
"
