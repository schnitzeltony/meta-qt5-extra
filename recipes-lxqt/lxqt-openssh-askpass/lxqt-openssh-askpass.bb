SUMMARY = "This is a very small helper app for ssh-agent"
LICENSE = "LGPL-2.1"
LIC_FILES_CHKSUM = "file://LICENSE;md5=435ed639f84d4585d93824e7da3d85da"

inherit lxqt qt5-translation

DEPENDS += "liblxqt"

SRCREV = "25eda5f5fe521f0c9d578577258ca9380f49750b"
PV = "1.0.0"
