SUMMARY = "Library used to query system info and statistics "
LICENSE = "LGPL-2.1-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=435ed639f84d4585d93824e7da3d85da"

inherit lxqt

SRCREV = "a4f05535c12c4d895b715c9c9ac819aba5530739"
PV = "0.4.6"
