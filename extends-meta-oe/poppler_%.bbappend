PACKAGECONFIG_append = " qt5"

inherit cmake_qt5
