PACKAGECONFIG:append = " qt5"
