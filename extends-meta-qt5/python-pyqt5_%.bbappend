DISABLED_FEATURES = ""

PACKAGECONFIG_append = " \
    sql \
    \
    qtlocation \
    qtmultimedia \
    qtdeclarative \
    qtsensors \
    qtserialport \
    qtsvg \
    qtwebchannel \
    qtwebengine \
    qtwebkit \
    qtwebsockets \
    qtx11extras \
    qtxmlpatterns \
"
