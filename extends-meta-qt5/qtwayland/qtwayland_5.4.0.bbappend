FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-QWaylandOutput-to-support-multiple-outputs.patch"
