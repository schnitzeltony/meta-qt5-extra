require ${BPN}.inc

inherit native

SRC_URI += "file://0001-Just-build-bare-kdwsdl2cpp-for-native.patch"
